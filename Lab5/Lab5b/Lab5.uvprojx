# Keil uVision project Lab5.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\TivaWare_C_Series-2.2.0.295;..\..\..\TivaWare_C_Series-2.2.0.295\driverlib\rvmdk;.\src_my;.\src_other;.\Libraries;..\..\..\dougrenaux_ELEW32_public\ThreadX_demo\ModifiedSource;..\..\..\threadx\ports\cortex_m4\keil\example_build\lib_obj;..\..\..\..\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\..\..\ThreadX\ports\cortex_m4\keil\inc;..\..\..\ThreadX\common\inc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_my
    ./src_my/: main.c
  group src_other
    ../Lab5a/ThreadX_demo/ModifiedSource/: tx_initialize_low_level.s system_TM4C129.c startup_TM4C129.s TM4C1294NCPDT.h
  group Libraries
    ../../../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../../../threadx/ports/cortex_m4/keil/example_build/lib_obj/: ThreadX_Library.lib
software components: CMSIS:CORE 6.2.0
