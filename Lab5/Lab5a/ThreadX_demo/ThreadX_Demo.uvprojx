# Keil uVision project ThreadX_Demo.uvprojx, settings and files
target ThreadX_Demo (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ThreadX_Demo
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5
  c define: PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c include: .;.\ModifiedSource;..\..\..\..\ThreadX\common\inc;..\..\..\..\ThreadX\ports\cortex_m4\keil\inc;..\..\..\..\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\..\..\..\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --first __tx_vectors
  group ModifiedSource
    ./ModifiedSource/: demo_threadx.c TM4C1294NCPDT.h tx_initialize_low_level.s system_TM4C129.c startup_TM4C129.s
  group Library_Group
    ../../../../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../../../../threadx/ports/cortex_m4/keil/example_build/lib_obj/: ThreadX_Library.lib
software components: CMSIS:CORE 6.2.0
