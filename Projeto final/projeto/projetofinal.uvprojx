# Keil uVision project projetofinal.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projetofinal
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C1294NCPDT,TARGET_IS_TM4C129_RA1
  c include: ..\..\..\TivaWare_C_Series-2.2.0.295;..\..\..\TivaWare_C_Series-2.2.0.295\examples\boards\ek-tm4c1294xl;..\..\..\threadx\ports\cortex_m4\keil\inc;..\..\..\threadx\common\inc;..\..\..\TivaWare_C_Series-2.2.0.295\grlib;.\src_other;..\..\..\dougrenaux_ELEW32_public\display_demo\src_other
  asm define: TX_ENABLE_WFI
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_my
    ./: display.h display.c simula.c simula.h main.c hardware.c hardware.h
  group src_other
    ../../../dougrenaux_ELEW32_public/display_demo/src_other/: Crystalfontz128x128_ST7735.c Crystalfontz128x128_ST7735.h HAL_EK_TM4C1294XL_Crystalfontz128x128_ST7735.c HAL_EK_TM4C1294XL_Crystalfontz128x128_ST7735.h
  group libraries
    ../../../threadx/ports/cortex_m4/keil/example_build/lib_obj/: ThreadX_Library.lib
    ../../../dougrenaux_ELEW32_public/ThreadX_demo/ModifiedSource/: startup_TM4C129.s system_TM4C129.c TM4C1294NCPDT.h tx_initialize_low_level.s
    ../../../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../../../TivaWare_C_Series-2.2.0.295/grlib/rvmdk/: grlib.lib
software components: CMSIS:CORE 6.2.0
