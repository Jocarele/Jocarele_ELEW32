# Keil uVision project lab6.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab6
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-macro-redefined
  c include: ..\..\..\threadX;.\src_others;..\..\..\Tivaware_C_Series-2.2.0.295;..\..\..\Tivaware_C_Series-2.2.0.295\driverlib;..\..\..\Tivaware_C_Series-2.2.0.295\utils;..\..\..\threadx\ports\cortex_m4\keil\example_build\lib_obj\ThreadX_Library.lib;..\..\..\threadx\ports\cortex_m4\keil\example_build;..\..\..\threadx\common\inc;..\..\..\threadx\ports\cortex_m4\keil\inc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_my
    ./: main.c
  group src_others
    ./src_others/: driverlib.lib uartstdio.c uartstdio.h
  group New Group
    ../../../threadx/ports/cortex_m4/keil/example_build/lib_obj/: ThreadX_Library.lib
    ../../../dougrenaux_ELEW32_public/ThreadX_demo/ModifiedSource/: tx_initialize_low_level.s startup_TM4C129.s system_TM4C129.c TM4C1294NCPDT.h
software components: CMSIS:CORE 6.2.0
