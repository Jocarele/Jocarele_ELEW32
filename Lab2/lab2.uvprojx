# Keil uVision project lab2.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Tivaware_C_Series-2.2.0.285;..\..\Tivaware_C_Series-2.2.0.285\utils;..\..\Tivaware_C_Series-2.2.0.285\driverlib
  asm include: ..\..\Tivaware_C_Series-2.2.0.285;..\..\Tivaware_C_Series-2.2.0.285\driverlib;..\..\Tivaware_C_Series-2.2.0.285\utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_my
    ./src_others/: main.c
  group src_others
    ./src_others/: BTN.c BTN.h LED.c LED.h TM4C1294NCPDT.h
    ../../Tivaware_C_Series-2.2.0.285/utils/: uartstdio.c uartstdio.h
    ../../Tivaware_C_Series-2.2.0.285/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
