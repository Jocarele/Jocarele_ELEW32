# Keil uVision project lab4b.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab4a
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-sign-conversion
-Wno-implicit-int-conversion
-Wno-c11-extensions
  c include: .\src_others;C:\ti\TivaWare_C_Series-2.2.0.295;C:\ti\TivaWare_C_Series-2.2.0.295\driverlib;C:\ti\TivaWare_C_Series-2.2.0.295\utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_my
    ./src_my/: main.c main.h thousands_pulse.S
  group src_others
    ./src_others/: uartstdio.c uartstdio.h driverlib.lib
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
